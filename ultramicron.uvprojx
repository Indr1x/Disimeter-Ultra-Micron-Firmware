# Keil uVision project ultramicron.uvprojx, settings and files
target Ultra-Micron 4.02+ service (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: Ultra-Micron_4_02_service +hex
  BeforeMake: indent-2.2.10-bin\bin\indent.exe -kr -l150 -bli0 -di1 -i2 -bbo -nip -lp -nbad -nsai -bl -bls -nut  main.c include/*.c include/*.h include/display/*.c include/display/*.h
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM32L152_EVAL, STM32L1XX_MD version_401 service
  c misc: --debug
  c include: .\include;.\include\control;.\include\display;.\STM32L1xx_StdPeriph_Lib_V1.3.1\Libraries\STM32L1xx_StdPeriph_Driver\inc;.\STM32L1xx_StdPeriph_Lib_V1.3.1\Project\STM32L1xx_StdPeriph_Templates;.\STM32_USB-FS-Device_Lib_V4.0.0\Projects\VirtualComport_Loopback\inc;.\STM32_USB-FS-Device_Lib_V4.0.0\Libraries\STM32_USB-FS-Device_Driver\inc;.\STM32_USB-FS-Device_Lib_V4.0.0\Projects\VirtualComport_Loopback\inc;.\STM32L1xx_StdPeriph_Lib_V1.3.1\Libraries\CMSIS\Include
  memory RVCT4: ROM 0x8003000 size 0xbfff
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ./: system_stm32l1xx.c
    ./STM32L1xx_StdPeriph_Lib_V1.3.1/Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
    ./STM32L1xx_StdPeriph_Lib_V1.3.1/Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group Includes
    ./include/: timers.c adc.c comp.c clock.c dac.c delay.c io_ports.c interrupt.c keys.c menu.c rtc.c power.c usb.c
    ./include/display/: ext2760.c
  group Main
    ./: main.c
  group USB-FS_Device_Driver
    ./STM32_USB-FS-Device_Lib_V4.0.0/Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB_User_Virtual_com
    ./STM32_USB-FS-Device_Lib_V4.0.0/Projects/VirtualComport_Loopback/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group Includes_code_in_RAM
    ./include/: stm32l1xx_it.c services.c eeprom.c flash_save.c
target Ultra-Micron 4.02+ (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ultra-Micron_4_02 +hex
  AfterMake: C:\Проекты\Ультра-микрон\firmware\clear.bat
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM32L152_EVAL, STM32L1XX_MD version_401
  c misc: --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xbfff
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ultra-Micron 3.00+ (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ultra-Micron_3_00 +hex
  AfterMake: C:\Проекты\Ультра-микрон\firmware\clear.bat
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM32L152_EVAL, STM32L1XX_MD version_300
  c misc: --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xbfff
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ultra-Micron 2.04+ (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ultra-Micron_2_04 +hex
  AfterMake: C:\Проекты\Ультра-микрон\firmware\clear.bat
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM32L152_EVAL, STM32L1XX_MD version_204
  c misc: --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xbfff
  memory RVCT9: RAM 0x20000000 size 0x4000
target Ultra-Micron 4.02+ EN (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L152CB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.0.2
  cpu: as above
  output: Ultra-Micron_4_02_EN +hex
  AfterMake: C:\Проекты\Ультра-микрон\firmware\clear.bat
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM32L152_EVAL, STM32L1XX_MD version_401 LANG_EN
  c misc: --debug
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8003000 size 0xbfff
  memory RVCT9: RAM 0x20000000 size 0x4000
